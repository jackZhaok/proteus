; AT89C51, 11.0592 MHz, AS31 syntax
; P1 = DAC0808; P0 = ADC0804; LCD on P2 (4-bit)
.equ LCD_RS, 0A0h
.equ LCD_E, 0A1h
.equ LED_N, 0A2h
.equ BEEP_N, 0A3h
.equ ADC_WR, 0B5h
.equ ADC_RD, 0B6h
.equ ADC_INTR, 0B7h
.equ CODE, 030h
.equ CURRENT, 031h
.equ KEY_PREV, 032h
.equ KEY_STABLE, 033h
.equ KEY_EDGE, 034h
.equ DIGIT, 035h
.equ OUTMODE, 036h
.equ SCAN, 037h
.equ SCAN_DIV, 038h
.equ PORT_SHADOW, 039h
.equ SCAN_MAX, 100
.equ ALARM_MAG, 80

.org 0000h
    LJMP START

.org 0030h
START:
    MOV SP,#05Fh
    MOV P0,#0FFh
    MOV P3,#0FFh
    MOV PORT_SHADOW,#00Ch
    MOV P2,PORT_SHADOW
    MOV CODE,#0
    MOV P1,#0
    MOV SCAN,#0
    MOV SCAN_DIV,#0
    MOV KEY_PREV,#0
    MOV KEY_STABLE,#0
    MOV TMOD,#021h
    MOV TH1,#0FDh
    MOV TL1,#0FDh
    MOV SCON,#050h
    SETB TR1
    LCALL LCD_INIT
    LCALL TIMER_START

MAIN:
    JNB TF0,MAIN
    LCALL TIMER_START
    LCALL ADC_READ
    JC ADC_ERROR
    LCALL ALARM_UPDATE
    LCALL LCD_SHOW
    LCALL UART_ROW
    SJMP NEXT_STEP
ADC_ERROR:
    LCALL ALARM_OFF
    MOV A,#0C0h
    LCALL LCD_CMD
    MOV DPTR,#ADC_FAIL_TEXT
    MOV OUTMODE,#0
    LCALL PRINT_STRING
    MOV SCAN,#0
NEXT_STEP:
    LCALL KEY_READ
    LCALL UPDATE_SETPOINT
    MOV P1,CODE
    SJMP MAIN

; Timer 0: 46080 machine cycles = 50 ms
TIMER_START:
    CLR TR0
    CLR TF0
    MOV TH0,#04Ch
    MOV TL0,#00h
    SETB TR0
    RET

; Report a press only after two matching samples.
KEY_READ:
    MOV KEY_EDGE,#0
    MOV A,P3
    CPL A
    ANL A,#01Ch
    CJNE A,KEY_PREV,KEY_CHANGED
    XRL A,KEY_STABLE
    ANL A,KEY_PREV
    MOV KEY_EDGE,A
    MOV KEY_STABLE,KEY_PREV
    RET
KEY_CHANGED:
    MOV KEY_PREV,A
    RET

UPDATE_SETPOINT:
    MOV A,KEY_EDGE
    JB ACC.4,SCAN_BUTTON
    MOV A,SCAN
    JNZ RUN_SCAN
    MOV A,KEY_EDGE
    JB ACC.2,SET_PLUS
    JNB ACC.3,SET_DONE
    MOV A,CODE
    JZ SET_DONE
    DEC CODE
SET_DONE:
    RET
SET_PLUS:
    MOV A,CODE
    CJNE A,#SCAN_MAX,STEP_PLUS
    RET
STEP_PLUS:
    INC CODE
    RET
SCAN_BUTTON:
    MOV A,SCAN
    JNZ SCAN_STOP
    MOV SCAN,#1
    MOV SCAN_DIV,#2
    MOV CODE,#0
    RET
RUN_SCAN:
    DJNZ SCAN_DIV,SET_DONE
    MOV SCAN_DIV,#2
    MOV A,CODE
    CJNE A,#SCAN_MAX,STEP_PLUS
SCAN_STOP:
    MOV SCAN,#0
    RET

ADC_READ:
    CLR ADC_WR
    NOP
    SETB ADC_WR
    MOV R7,#255
ADC_WAIT:
    JNB ADC_INTR,ADC_READY
    DJNZ R7,ADC_WAIT
    SETB C
    RET
ADC_READY:
    CLR ADC_RD
    NOP
    MOV A,P0
    SETB ADC_RD
    MOV CURRENT,A
    CLR C
    RET

; Vin = 2.5 V + 19.531 kOhm * I. 1 count ~ 1 uA.
CURRENT_MAG:
    MOV A,CURRENT
    CLR C
    SUBB A,#128
    JNC MAG_DONE
    CPL A
    INC A
    SETB C
MAG_DONE:
    RET

ALARM_UPDATE:
    LCALL CURRENT_MAG
    CLR C
    SUBB A,#ALARM_MAG
    JC ALARM_OFF
    ANL PORT_SHADOW,#0F3h
    MOV P2,PORT_SHADOW
    RET
ALARM_OFF:
    ORL PORT_SHADOW,#00Ch
    MOV P2,PORT_SHADOW
    RET

LCD_SHOW:
    MOV OUTMODE,#0
    MOV A,#080h
    LCALL LCD_CMD
    MOV DPTR,#E_LABEL
    LCALL PRINT_STRING
    LCALL PRINT_E
    MOV DPTR,#MV_LABEL
    LCALL PRINT_STRING
    MOV A,SCAN
    JZ LCD_HOLD
    MOV DPTR,#SCAN_TEXT
    SJMP LCD_STATUS
LCD_HOLD:
    MOV DPTR,#HOLD_TEXT
LCD_STATUS:
    LCALL PRINT_STRING
    MOV A,#0C0h
    LCALL LCD_CMD
    MOV DPTR,#I_LABEL
    LCALL PRINT_STRING
    LCALL PRINT_I
    MOV DPTR,#UA_LABEL
    LCALL PRINT_STRING
    MOV A,PORT_SHADOW
    JB ACC.2,LCD_NORMAL
    MOV DPTR,#ALARM_TEXT
    LJMP PRINT_STRING
LCD_NORMAL:
    MOV DPTR,#NORMAL_TEXT
    LJMP PRINT_STRING

UART_ROW:
    MOV OUTMODE,#1
    LCALL PRINT_E
    MOV A,#','
    LCALL EMIT
    LCALL PRINT_I
    MOV A,#13
    LCALL EMIT
    MOV A,#10
    LJMP EMIT

PRINT_E:
    MOV A,#'-'
    LCALL EMIT
    MOV A,CODE
    MOV B,#100
    DIV AB
    ADD A,#'0'
    MOV DIGIT,B
    LCALL EMIT
    MOV A,DIGIT
    LCALL PRINT_2
    MOV A,#'0'
    LJMP EMIT

PRINT_I:
    LCALL CURRENT_MAG
    MOV DIGIT,A
    MOV A,#'+'
    JNC I_SIGN
    MOV A,#'-'
I_SIGN:
    LCALL EMIT
    MOV A,DIGIT
    MOV B,#100
    DIV AB
    MOV DIGIT,B
    ADD A,#'0'
    LCALL EMIT
    MOV A,DIGIT
PRINT_2:
    MOV B,#10
    DIV AB
    MOV DIGIT,B
    ADD A,#'0'
    LCALL EMIT
    MOV A,DIGIT
    ADD A,#'0'
    LJMP EMIT

PRINT_STRING:
    CLR A
    MOVC A,@A+DPTR
    JZ STRING_DONE
    LCALL EMIT
    INC DPTR
    SJMP PRINT_STRING
STRING_DONE:
    RET

EMIT:
    XCH A,OUTMODE
    JNZ EMIT_UART
    XCH A,OUTMODE

    ORL PORT_SHADOW,#1
    SJMP LCD_BYTE
EMIT_UART:
    XCH A,OUTMODE
    CLR TI
    MOV SBUF,A
UART_WAIT:
    JNB TI,UART_WAIT
    RET

LCD_CMD:
    ANL PORT_SHADOW,#0FEh
LCD_BYTE:
    MOV R5,A
    LCALL LCD_NIBBLE
    MOV A,R5
    SWAP A
    LCALL LCD_NIBBLE
    MOV R6,#1
    SJMP DELAY_MS

LCD_NIBBLE:
    ANL A,#0F0h
    ORL A,PORT_SHADOW
    MOV P2,A
    SETB LCD_E
    NOP
    CLR LCD_E
    RET

LCD_INIT:
    MOV R6,#25
    LCALL DELAY_MS
    MOV A,#030h
    LCALL LCD_NIBBLE
    MOV R6,#5
    LCALL DELAY_MS
    MOV A,#030h
    LCALL LCD_NIBBLE
    MOV R6,#1
    LCALL DELAY_MS
    MOV A,#030h
    LCALL LCD_NIBBLE
    MOV R6,#1
    LCALL DELAY_MS
    MOV A,#020h
    LCALL LCD_NIBBLE
    ; Wait for the 4-bit function set before sending the two-line command.
    MOV R6,#1
    LCALL DELAY_MS
    MOV A,#028h
    LCALL LCD_CMD
    MOV A,#00Ch
    LCALL LCD_CMD
    MOV A,#006h
    LCALL LCD_CMD
    MOV A,#001h
    LCALL LCD_CMD
    MOV R6,#4
DELAY_MS:
    MOV R7,#230
DELAY_INNER:
    DJNZ R7,DELAY_INNER
    DJNZ R6,DELAY_MS
    RET

E_LABEL: .byte "E=",0
I_LABEL: .byte "I=",0
MV_LABEL: .byte "mV ",0
UA_LABEL: .byte "uA ",0
SCAN_TEXT: .byte "SCAN  ",0
HOLD_TEXT: .byte "HOLD  ",0
ALARM_TEXT: .byte "ALARM  ",0
NORMAL_TEXT: .byte "OK     ",0
ADC_FAIL_TEXT: .byte "ADC TIMEOUT     ",0
